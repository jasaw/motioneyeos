## package/ldr-reader/Config.in
```kconfig
config BR2_PACKAGE_LDR_READER
	bool "ldr-reader"
	help
	  Reads analog Light Dependent Resistor using sysfs gpio interface.
```
